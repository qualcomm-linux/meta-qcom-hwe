RRECOMMENDS:${PN}:remove:qcom-custom-bsp = "mesa-vulkan-drivers"
