inherit qprebuilt

LICENSE          = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DESCRIPTION = "Camx Autogen"

QCS9100_SHA256SUM = "24a76d270ba383968d8afd4322c326cdb10433242473a706cec3143318d9a3f1"
QCS8300_SHA256SUM = "598f5cf2ec1f47c9233a569989eecab43f74e8e7363fdcfe1e4ce59ffdec3bc6"
QCS615_SHA256SUM = "125553fb375c01be8ceb7935757ba8f47ae8af8545feca067354ec69789286bd"

SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"

