inherit qprebuilt pkgconfig

LICENSE          = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DESCRIPTION = "Qualcomm Atheros ath6kl utils."

DEPENDS += "diag libnl glib-2.0"

PV = "1.0"

QCM6490_SHA256SUM = "b004391efe29a61e2dce087a6e8224e0ff1d90c44d7db9213205838ba709e99b"
QCS9100_SHA256SUM = "4ec677bd428a9ddab986edb5041ec6b49f9f1fdf9c90c67da626846401e04362"
QCS8300_SHA256SUM = "a1861683c5000cefc11a21c658f5e339843cef26058589bb886a7d0455b3aab3"
QCS615_SHA256SUM = "5b25de70542511708d1fe1505d7d74a134fe2cad6b05fc2630791bd35729fd63"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"
