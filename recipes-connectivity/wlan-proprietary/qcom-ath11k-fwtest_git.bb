inherit qprebuilt pkgconfig

LICENSE          = "Qualcomm-Technologies-Inc.-Proprietary"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=58d50a3d36f27f1a1e6089308a49b403"

DESCRIPTION = "Qualcomm Technologies ath11k-fwtest"

DEPENDS += "libnl"

PV = "1.0"

QCM6490_SHA256SUM = "4e5446db9de00f30e2800a88123e3054e0129b6dfac50a8665dff728341b1cce"
QCS9100_SHA256SUM = "e382bcaea2d2469094bcdd8840ca8910acaee53c32a86a462594d1c3acf2aafb"
QCS8300_SHA256SUM = "081b05ac8b77a41a597ec95cadec9ea4431b0b09ebaa179527b99b92d56ca741"
QCS615_SHA256SUM = "741f4f6aaf52e54ea900dc9f4a4d2ae512476845937ea505080b4885fd103dbe"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"
