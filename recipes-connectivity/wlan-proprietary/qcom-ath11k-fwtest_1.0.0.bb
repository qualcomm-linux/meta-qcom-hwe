inherit qprebuilt pkgconfig

LICENSE          = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DESCRIPTION = "Qualcomm Technologies ath11k-fwtest"

DEPENDS += "libnl"

PV = "1.0"

QCM6490_SHA256SUM = "6fe6bb4e6ba915dd4a37c7fc250cc506bb6850e7db8e42c7b52fab15f9189d30"
QCS9100_SHA256SUM = "b9f966a3c1a11cdb1d341cc53e7f1efafedbe79a1d5de8169de967304c76fd23"
QCS8300_SHA256SUM = "19781b5ac5b0a0d0e22384680f90efd2c07e240664d73a9dd62e7137aab1d0aa"
QCS615_SHA256SUM = "93b94158539ce863166b698d860e0dbb1475396fa54d11f0d016d689b94724bc"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"
