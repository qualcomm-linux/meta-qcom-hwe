inherit autotools-brokensep pkgconfig qprebuilt

DESCRIPTION = "Qualcomm Technologies Ctrl App Dut Tool"
LICENSE     = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DEPENDS += "libnl glib-2.0"
PV = "1.0"

QCM6490_SHA256SUM = "746a4b388164c90ea91f9b69e5ef363b05600c7f8051e67681f01bdd438408cb"
QCS9100_SHA256SUM = "bc4ec8bea0c52b377665a18e5e44b9483b906da0278ae745fe1e55125278ff67"
QCS8300_SHA256SUM = "eb3170abae25af2070bfadf4eb4f8eb438fd208068ef698f793be03dee561f0d"
QCS615_SHA256SUM = "fe72bd9c844446daac95d0a15444a912d9d709b2d8ffc13c646887827f703e7c"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"
