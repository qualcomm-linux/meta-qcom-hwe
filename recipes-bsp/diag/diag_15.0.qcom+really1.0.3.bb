inherit qprebuilt pkgconfig systemd

LICENSE          = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DESCRIPTION = "Library and routing applications for diagnostic traffic"

DEPENDS += "glib-2.0 time-genoff"

QCM6490_SHA256SUM = "21430419c752f00aa9fe052e409527278773286bc9b18afca4917038cf4e4de8"
QCS9100_SHA256SUM = "6278777657f91e0c24424547240b005eee1a46566cdd400db30fbe7300c00385"
QCS8300_SHA256SUM = "6fdd82dec5dc98f39d366880d23e1dd5983851ae224233683a2be8cbae81840e"
QCS615_SHA256SUM = "e83f3b65f37f073694dadfd9988e3ff6ffecf1bbd412ea2add29646956395276"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"

FILES:${PN} += "${systemd_unitdir}/system/"

