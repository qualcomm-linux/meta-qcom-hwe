inherit qprebuilt pkgconfig

LICENSE          = "LICENSE.qcom-2"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=165287851294f2fb8ac8cbc5e24b02b0"

DESCRIPTION = "Time Genoff Library"

QCM6490_SHA256SUM = "a4ee8c1748efd28fdf2557c3b07d5baeecf83cbccad064d93d1d3112508e65ce"
QCS9100_SHA256SUM = "2dd005db861b8bb2558809f14f31899f98012c4b01ccfe1b996e8fc49fb4b67d"
QCS8300_SHA256SUM = "3a72f50dc784d5c2675a1b12d243ec960873b4aead7b0bd44edafc350a8576ff"
QCS615_SHA256SUM = "3bdedc9bb79759a7ab8167939d70db4c2687ba9e585ab2b5cc4e8adb68f063bb"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"
