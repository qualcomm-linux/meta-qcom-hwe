inherit qprebuilt pkgconfig

LICENSE          = "Qualcomm-Technologies-Inc.-Proprietary"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=58d50a3d36f27f1a1e6089308a49b403"

DESCRIPTION = "Time Genoff Library"

QCM6490_SHA256SUM = "8ad4c506a9fd144d6d97d5f70e8dceea30270e0a079758315fa5b95738d07839"
QCS9100_SHA256SUM = "5e5044fe07106ab97b6a9e9a10bdcb09134bb7d4c8b0b7087f1648f5e35eb1c7"
QCS8300_SHA256SUM = "817da3b98c08daf120afe13068292c41ddfc37bdf11bc15069c1597061afcfd7"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"
