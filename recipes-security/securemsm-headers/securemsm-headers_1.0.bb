inherit qprebuilt pkgconfig

LICENSE          = "Qualcomm-Technologies-Inc.-Proprietary"
LIC_FILES_CHKSUM = "file://${QCOM_COMMON_LICENSE_DIR}${LICENSE};md5=58d50a3d36f27f1a1e6089308a49b403"

DESCRIPTION = "Securemsm headers"

QCM6490_SHA256SUM = "cea77cd4ed957b2db10291eb118a22b5e2ac5b75e1636fab987570951ac8f018"
QCS9100_SHA256SUM = "7efaf0823e373e0c557dcf403ba43dde959bd3e683231c02eaed515f7a420df9"
QCS8300_SHA256SUM = "7c82d15d3690292f15b1e64e42c5fec39d53a96846b2b0b75089c4d73744f98d"
QCS615_SHA256SUM = "eb679e91f83caea93da5357ea299f1dfd39135a4480584a15039440eb98b1769"

SRC_URI[qcm6490.sha256sum] = "${QCM6490_SHA256SUM}"
SRC_URI[qcs9100.sha256sum] = "${QCS9100_SHA256SUM}"
SRC_URI[qcs8300.sha256sum] = "${QCS8300_SHA256SUM}"
SRC_URI[qcs615.sha256sum] = "${QCS615_SHA256SUM}"

SRC_URI = "${PBT_ARTIFACTORY}/${PBT_BUILD_ID}/${PBT_BIN_PATH}/${BPN}_${PV}_${PBT_ARCH}.tar.gz;name=${PBT_ARCH}"

ALLOW_EMPTY:${PN} = "1"
